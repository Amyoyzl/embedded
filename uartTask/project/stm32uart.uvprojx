# Keil uVision project stm32uart.uvprojx, settings and files
target uartTask (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32uart
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\system\delay;..\system\sys;..\system\usart;..\system\lcd
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c startup_stm32f40_41xxx.s
    ../system/usart/: usart.c usart.h
  group hardware
    ../hardware/lcd/: ILI93xx.c
    ../hardware/led/: myled.c
    ../hardware/uart/: myuart2.c
  group user
    ../user/: main.c
